# IAR project Backup (3) of SPPLEDemo.ewp, settings and files
configuration Debug - MSP430F5438A Exp (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlmfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 1200
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: BTPSVEND_PATCH_LOCATION=__data20; __SUPPORT_LOW_ENERGY__; BTPS_MEMORY_BUFFER_SIZE=9600; __DISABLE_SMCLK__
  ICC430.CCDiagSuppress: Pa050
  ICC430.newCCIncludePaths: ..\..\..\..\Bluetopia\include; ..\..\..\..\Bluetopia\btpskrnl; ..\..\..\..\Bluetopia\btpsvend; ..\..\..\..\Bluetopia\btvs; ..\..\..\..\Bluetopia\hcitrans; ..\..\..\..\Bluetopia\profiles\gatt\include; ..\..\..\..\Bluetopia\profiles\gaps\include; ..\..\..\..\Hardware; ..\..\..\..\Hardware\MSP430_EXP5438
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5438a.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: -C ..\..\..\..\Bluetopia\lib\IAR\DefaultMTU\libBluetopia_LE.a; -C ..\..\..\..\Bluetopia\profiles\GATT\lib\IAR\libSS1BTGAT.a; -C ..\..\..\..\Bluetopia\profiles\GAPS\lib\IAR\libSS1BTGAP.a
configuration Release - MSP430F5438A Exp (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xmfn.h
  ICC430.CCDefines: BTPSVEND_PATCH_LOCATION=__data20; __SUPPORT_LOW_ENERGY__; BTPS_MEMORY_BUFFER_SIZE=3600; __DISABLE_SMCLK__
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
configuration Debug - ez430 (MSP430, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xmfn.h
  General.OGChipSelectMenu: MSP430BT5190 MSP430BT5190
  ICC430.CCDefines: as above
  ICC430.newCCIncludePaths: ..\..\..\..\Bluetopia\include; ..\..\..\..\Bluetopia\btpskrnl; ..\..\..\..\Bluetopia\btpsvend; ..\..\..\..\Bluetopia\btvs; ..\..\..\..\Bluetopia\hcitrans; ..\..\..\..\Bluetopia\profiles\gatt\include; ..\..\..\..\Bluetopia\profiles\gaps\include; ..\..\..\..\Hardware; ..\..\..\..\Hardware\ez430
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430BT5190.xcl
configuration Release - ez430 (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430BT5190 MSP430BT5190
  ICC430.CCDefines: as above
  ICC430.newCCIncludePaths: as above
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430BT5190.xcl
  group Bluetopia/BTPSKRNL
    ../../../../Bluetopia/btpskrnl/: BKRNLAPI.h BTPSKRNL.c BTPSKRNL.h sprintf.c sprintf.h
  group Bluetopia/BTPSVEND
    ../../../../Bluetopia/btpsvend/: BTPSVEND.c BTPSVEND.h BVENDAPI.h
  group Bluetopia/BTVS
    ../../../../Bluetopia/btvs/: BTVS.c BTVSAPI.h SS1BTVS.h
  group Bluetopia/HCITRANS
    ../../../../Bluetopia/hcitrans/: HCITRANS.c HCITRANS.h
  group Bluetopia/Include
    ../../../../Bluetopia/include/: BaseTypes.h BSCAPI.h BTAPITyp.h BTBTypes.h BTErrors.h BTPSCFG.h BTPSVER.h BTTypes.h GAPAPI.h GOEPAPI.h HCIAPI.h HCICommT.h HCIDRV.h HCITypes.h HCIUSBT.h L2CAPAPI.h L2CAPTyp.h OBXTypes.h OTPAPI.h RFCOMAPI.h RFCOMMT.h SCOAPI.h SDPAPI.h SDPTypes.h SMTypes.h SPPAPI.h SS1BTPS.h
  group Hardware
    ../../../../Hardware/: low_level_init.c MSP430Utils.h
  group Hardware/ez430
    ../../../../Hardware/ez430/: HAL.c HAL.h HRDWCFG.h
  group Hardware/MSP430_EXP5438
    ../../../../Hardware/MSP430_EXP5438/: HAL.c HAL.h HRDWCFG.h
  group SPPLEDemo
    ../../: Main.c Main.h SPPLEDemo.c SPPLEDemo.h SPPLETyp.h
